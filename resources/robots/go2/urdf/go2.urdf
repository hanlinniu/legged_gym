Commit message: removed the camera box

File: resources/robots/go2/urdf/go2.urdf (robot description, URDF)
Before this commit: robot go2_description, 30 links, 29 joints
Links:
- removed link camera_box
Joints:
- removed joint fixed_camera_box
